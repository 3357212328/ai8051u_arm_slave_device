# Keil uVision project ai8051u_templete.uvproj, settings and files
target code (MCS-251)
  device: AI8051U-32Bit Series AI
  cpu: IRAM(0-0x7FF) XRAM(0x10000-0x17FFF) IROM(0xFF0000-0xFFFFFF) CLOCK(35000000)
  output: ai8051u_templete +hex
  link misc: REMOVEUNUSED
  group user
    ./: main.c
  group hardware
    ./: delay.c delay.h flash_if.c flash_if.h pca9685.c pca9685.h OLED.c OLED.h OLED_Data.c OLED_Data.h keypad.c keypad.h encoder.c encoder.h DHT11.c DHT11.h Buzzer.c Buzzer.h uart.c uart.h
  group library
    ./: set_eeprom.c set_eeprom.h set_i2c.c set_i2c.h set_io.c set_io.h set_timer.c set_timer.h set_uart.c set_uart.h TFPU_C251.LIB MDU32_C251.LIB
